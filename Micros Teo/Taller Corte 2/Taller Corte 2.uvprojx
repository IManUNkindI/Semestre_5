# Keil uVision project Taller Corte 2.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F767ZITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.15.2
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x200000) IROM2(0x00200000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Taller Corte 2
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: Taller Corte 2.cpp SysTick.h I2C.h LCD-Comm-Write.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.2.5
