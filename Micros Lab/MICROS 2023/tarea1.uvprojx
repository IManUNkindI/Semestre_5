# Keil uVision project tarea1.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: STM32F767ZGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.14.1
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: tarea1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: tarea1.cpp
software components: CMSIS:CORE 5.6.0, Device:Startup 1.2.5
